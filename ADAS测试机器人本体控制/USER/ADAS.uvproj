# Keil uVision project ADAS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\CAN;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;.\SYSINIT;..\FreeRTOS\include;.\ALG;..\USER;..\HARDWARE\IIC;..\HARDWARE\GPS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: robot_action.c robot_action.h basicfunc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/CAN/: my_can.c
    ../HARDWARE/joystick/: joystick.c
  group SYSINIT
    ./SYSINIT/: sysinit.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group ALG
    ./ALG/: mainloop.c Comm2Controller.c
  group IIC
    ../HARDWARE/IIC/: myiic.c
