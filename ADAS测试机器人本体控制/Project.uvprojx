# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM7_LPC21xx;.\FreeRTOS\portable\RVDS\ARM_CA9;.\FreeRTOS\portable\RVDS\ARM_CM0;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS\portable\RVDS\ARM_CM4_MPU;.\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;.\HARDWARE\CAN;.\HARDWARE\GPS;.\HARDWARE\IIC;.\HARDWARE\joystick;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\MPU6050;.\HARDWARE\MPU6050\eMPL;.\HARDWARE\TIMER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\USER\ALG;.\USER\SYSINIT;
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c
  group FreeRTOS_include
    ./FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS_portable_MemMang
    ./FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group FreeRTOS_portable_RVDS_ARM7_LPC21xx
    ./FreeRTOS/portable/RVDS/ARM7_LPC21xx/: port.c portmacro.h
  group FreeRTOS_portable_RVDS_ARM_CA9
    ./FreeRTOS/portable/RVDS/ARM_CA9/: port.c portmacro.h
  group FreeRTOS_portable_RVDS_ARM_CM0
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c portmacro.h
  group FreeRTOS_portable_RVDS_ARM_CM3
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS_portable_RVDS_ARM_CM4_MPU
    ./FreeRTOS/portable/RVDS/ARM_CM4_MPU/: port.c portmacro.h
  group FreeRTOS_portable_RVDS_ARM_CM7_r0p1
    ./FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
  group HARDWARE_CAN
    ./HARDWARE/CAN/: canopen.c my_can.c canopen.h my_can.h
  group HARDWARE_GPS
    ./HARDWARE/GPS/: gps.c gps.h
  group HARDWARE_IIC
    ./HARDWARE/IIC/: myiic.c myiic.h
  group HARDWARE_joystick
    ./HARDWARE/joystick/: joystick.c joystick.h
  group HARDWARE_KEY
    ./HARDWARE/KEY/: key.c key.h
  group HARDWARE_LED
    ./HARDWARE/LED/: led.c led.h
  group HARDWARE_MPU6050
    ./HARDWARE/MPU6050/: mpu6050.c mpu6050.h
  group HARDWARE_MPU6050_eMPL
    ./HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c dmpKey.h dmpmap.h inv_mpu.h inv_mpu_dmp_motion_driver.h
  group HARDWARE_TIMER
    ./HARDWARE/TIMER/: timer.c timer.h
  group SYSTEM_delay
    ./SYSTEM/delay/: delay.c delay.h
  group SYSTEM_sys
    ./SYSTEM/sys/: sys.c stm32f4xx.h sys.h system_stm32f4xx.h
  group SYSTEM_usart
    ./SYSTEM/usart/: usart.c usart.h
  group USER
    ./USER/: basicfunc.c main.c robot_action.c basicfunc.h robot_action.h
  group USER_ALG
    ./USER/ALG/: Comm2Controller.c mainloop.c Comm2Controller.h mainloop.h taskconfigs.h
  group USER_SYSINIT
    ./USER/SYSINIT/: sysinit.c sysinit.h typeinclude.h
software components: CMSIS:CORE 4.1.0
